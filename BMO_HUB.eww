<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\BMO_HUB.ewp</path>
    </project>
    <batchBuild />
</workspace>
